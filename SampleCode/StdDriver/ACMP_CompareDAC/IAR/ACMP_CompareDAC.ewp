# IAR project ACMP_CompareDAC.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC1263AE series Nuvoton NUC1263AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\m2a23\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ACMP_CompareDAC.bin
  ILINK.IlinkOutputFile: ACMP_CompareDAC.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2A23/Source/IAR/: startup_m2a23.s
    ../../../../Library/Device/Nuvoton/M2A23/Source/: system_m2a23.c
  group Library
    ../../../../Library/StdDriver/src/: acmp.c clk.c dac.c retarget.c uart.c
  group User
    ../: main.c
