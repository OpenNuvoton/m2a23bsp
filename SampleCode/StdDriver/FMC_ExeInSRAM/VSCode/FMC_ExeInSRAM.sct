LOAD_ROM  0x0
{
	FLASH  +0
	{
		startup_m2a23.o (RESET, +FIRST)
		*.o (+RO)
	}
	
	SRAM  0x20000000 0x2000
	{
		* (+RW, +ZI)
	}

	exeinsram.bin 0x20002000 0x4000
	{
		exeinsram.o (+RO)
	}
}

