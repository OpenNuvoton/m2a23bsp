# Keil uVision project App.uvprojx, settings and files
target App (6190000::V6.19::ARMCLANG)
  device: M2A23SG5AC Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: App +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c include: ..\..\..\..\..\Library\Device\Nuvoton\m2a23\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\common\inc;..\..\..\..\..\Library\NuMaker\xmodem
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  link misc: --map --first='startup_m2a23.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/m2a23/Source/ARM/: startup_m2a23.S
    ../../../../../Library/Device/Nuvoton/m2a23/Source/: system_m2a23.c
  group User
    ../: main.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c clk.c uart.c sys.c fmc.c
    ../../../../../Library/NuMaker/xmodem/: xmodem.c
target NewApp (6190000::V6.19::ARMCLANG)
  device: NUC1263SD4AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: NewApp +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin" --output "..\..\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c define: NewApp
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: as above
