# IAR project App.ewp, settings and files
configuration App (ARM)
  General.OGChipSelectEditMenu: NUC1263AE series Nuvoton NUC1263AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Device\Nuvoton\m2a23\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..\common\inc; ..\..\..\..\..\Library\NuMaker\common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: App.bin
  ILINK.IlinkOutputFile: App.out
  ILINK.IlinkIcfFile: App.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration NewApp (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: M46xxIHAE series Nuvoton M46xxIHAE series
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; NewApp
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Device\Nuvoton\m466\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..\common\inc; ..\..\..\..\..\Library\NuMaker\common
  OBJCOPY.OOCOutputFile: NewApp.bin
  ILINK.IlinkOutputFile: NewApp.out
  group CMSIS
    ../../../../../Library/Device/Nuvoton/m2a23/Source/IAR/: startup_m2a23.s
    ../../../../../Library/Device/Nuvoton/m2a23/Source/: system_m2a23.c
  group Library
    ../../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
    ../../../../../Library/NuMaker/common/: xmodem.c
  group User
    ../: main.c
