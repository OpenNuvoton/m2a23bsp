# IAR project CANFD_CANFD_MonitorMode.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2A23xG5AC series Nuvoton M2A23xG5AC series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\m2a23\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CANFD_CANFD_MonitorMode.bin
  ILINK.IlinkOutputFile: CANFD_CANFD_MonitorMode.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m2a23/Source/IAR/: startup_m2a23.s
    ../../../../Library/Device/Nuvoton/m2a23/Source/: system_m2a23.c
  group Library
    ../../../../Library/StdDriver/src/: canfd.c clk.c gpio.c retarget.c sys.c uart.c
  group User
    ../: main.c
