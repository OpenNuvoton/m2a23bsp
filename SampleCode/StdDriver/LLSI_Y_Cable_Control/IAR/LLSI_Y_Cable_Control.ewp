# IAR project LLSI_Y_Cable_Control.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082, Pe144, Pe188, Pe513, Pe550
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\m2a23\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\LlsiYcableLib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LLSI_Y_Cable_Control.bin
  ILINK.IlinkOutputFile: LLSI_Y_Cable_Control.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m2a23/Source/IAR/: startup_m2a23.s
    ../../../../Library/Device/Nuvoton/m2a23/Source/: system_m2a23.c
  group Library
    ../../../../Library/StdDriver/src/: bpwm.c clk.c gpio.c llsi.c retarget.c sys.c timer.c uart.c
  group LlsiYcableLib
    ../../../../Library/LlsiYcableLib/: hdiv.c led_control.c led_gen2_control.c pdma_config.c
  group User
    ../: main.c
