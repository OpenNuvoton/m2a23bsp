# Keil uVision project FMC_MultiBoot.uvprojx, settings and files
target FMC_MultiBoot (6220000::V6.22::ARMCLANG)
  device: M2A23SG5AC Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.25
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: FMC
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 v6Lto=1
  c define: __BASE__
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\m2a23\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  link misc: --map --first='startup_m2a23.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m2a23/Source/ARM/: startup_m2a23.S
    ../../../../Library/Device/Nuvoton/m2a23/Source/: system_m2a23.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c fmc.c
target FMC_Boot0 (6220000::V6.22::ARMCLANG)
  device: M2A23SG5AC Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.25
  cpu: as above
  output: FMC_Boot0
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 v6Lto=1
  c define: __BOOT0__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  link misc: as above
target FMC_Boot1 (6220000::V6.22::ARMCLANG)
  device: M2A23SG5AC Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.25
  cpu: as above
  output: FMC_Boot1
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 v6Lto=1
  c define: __BOOT1__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  link misc: as above
target FMC_Boot2 (6220000::V6.22::ARMCLANG)
  device: M2A23SG5AC Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.25
  cpu: as above
  output: FMC_Boot2
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 v6Lto=1
  c define: __BOOT2__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  link misc: as above
target FMC_Boot3 (6220000::V6.22::ARMCLANG)
  device: M2A23SG5AC Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.25
  cpu: as above
  output: FMC_Boot3
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 v6Lto=1
  c define: __BOOT3__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  link misc: as above
target FMC_BootLD (6220000::V6.22::ARMCLANG)
  device: M2A23SG5AC Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.25
  cpu: as above
  output: FMC_BootLD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=1 v6LangP=1 v6Lto=1
  c define: FMC_BootLD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  link misc: as above
