# IAR project WDT_TimeoutWakeupAndReset.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2A23xG5AC series Nuvoton M2A23xG5AC series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\m2a23\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WDT_TimeoutWakeupAndReset.bin
  ILINK.IlinkOutputFile: WDT_TimeoutWakeupAndReset.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m2a23/Source/IAR/: startup_m2a23.s
    ../../../../Library/Device/Nuvoton/m2a23/Source/: system_m2a23.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c wdt.c
  group User
    ../: main.c
