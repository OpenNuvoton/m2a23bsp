# Keil uVision project Blinky.uvprojx, settings and files
target FreeRTOS (6230000::V6.23::ARMCLANG)
  device: M2A23SG5AC Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.7
  cpu: IRAM(0x20000000,0x3000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: Blinky
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\..\..\Library\Device\Nuvoton\m2a23\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM23_NTZ\non_secure;..\..\Blinky
  asm misc: -Wa,armasm,-DStack_Size=0x8000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='startup_m2a23.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m2a23/Source/: system_m2a23.c
    ../../../../Library/Device/Nuvoton/m2a23/Source/ARM/: startup_m2a23.S
  group Demo Files
    ../: main.c ParTest.c
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: QueueSet.c flash.c PollQ.c
  group FreeRTOS files
    ../../../../ThirdParty/FreeRTOS/Source/: tasks.c timers.c list.c queue.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM23_NTZ/non_secure/: port.c portasm.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c spi.c uart.c gpio.c
